Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable], RevitIdentifiers [VersionGUID: 71eb0cd7-8a20-4962-b7a1-2f8f804998d8, NumberOfSaves: 1]
File name: 0001
Time: 2024-09-11T13:08:04+01:00
Written by: ODA SDAI 23.12
Made in: Autodesk Revit 24.0.20.20 (ENU) - IFC 24.0.20.20

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 11094180_F_PWM908DV_LW:51908251_F_11094180_PWM908DV_LW, (2)
In: Default
Type - Material: z_Miele_Design_Orange, z_Miele_Design_Powder Coat_Lotus White, z_Miele_Design_Steel_Chrom, z_Miele_Design_Powder Coat_Grey, z_Miele_Design_Glass, z_Miele_Design_CLST, Polypropylene, z_Miele_Design_Glass Black, <Unnamed>, z_Miele_Connection_Water_IN, z_Miele_Design_Zinc_Steel, z_Miele_Connection_Electric, Default
Type - Pset_ProductRequirements - Category: Specialty Equipment
Pset_BuildingElementProxyCommon - Reference: 51908251_F_11094180_PWM908DV_LW; sets with these values: 2
